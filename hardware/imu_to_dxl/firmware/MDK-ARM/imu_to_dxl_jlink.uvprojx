# Keil uVision project imu_to_dxl_jlink.uvprojx, settings and files
target imu_to_dxl (6240000::V6.24::ARMCLANG)
  device: STM32G031F8Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(64000000) ELITTLE
  output: imu_to_dxl +hex
  AfterMake: "$KARM\ARMCLANG\bin\fromelf.exe" --bin --output "..\Build\imu_to_dxl.bin" "..\Build\imu_to_dxl.axf"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32G031xx,HSE_VALUE=16000000
  c misc: -std=c11 -Oz -gdwarf-4 -Wall -Wextra -Wno-unused-parameter
  c include: ..\Core\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32G0xx\Include;..\Drivers\LSM6DSV16X
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\imu_to_dxl.sct
  link misc: --entry=Reset_Handler --strict --info=stack
  group Application
    ../Core/Src/: main.c board.c control_table.c imu.c protocol.c
  group ST sensor driver
    ../Drivers/LSM6DSV16X/: lsm6dsv16x_reg.c
  group CMSIS and startup
    ../Drivers/CMSIS/Device/ST/STM32G0xx/Source/: system_stm32g0xx.c
    ../Startup/: startup_stm32g031xx.s
